# Keil uVision project STM32F4.uvproj, settings and files
target STM32F4 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F4 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F405xx, TRACE
  c include: ..\include;..\include\mylib;..\include\user;..\system\include\cmsis;..\system\include\stm32f4-stdperiph;..\system\include
  asm define: USE_STDPERIPH_DRIVER, STM32F405xx, TRACE
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\STM32F4.sct
  group system
    ../system/src/cmsis/: stack_heap_stm32f4xx.c system_stm32f4xx.c vectors_stm32f4xx.c
    ../system/src/cortexm/: _initialize_hardware.c _reset_hardware.c exception_handlers.c
    ../system/src/diag/: Trace.c trace_impl.c
    ../system/src/newlib/: _exit.c _sbrk.c _startup.c _syscalls.c assert.c
  group stdperiph
    ../system/src/stm32f4-stdperiph/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group mylib
    ../src/mylib/: 12864.c ad.c buzzer.c can1.c can2.c debug.c delay.c encoder.c exti.c hall.c key.c led.c oled.c pwm.c relay.c sensor.c tim6.c usart2.c usart3.c
  group user
    ../src/user/: app.c driver.c gyroscope.c main.c receiver.c stm32f4xx_it.c
